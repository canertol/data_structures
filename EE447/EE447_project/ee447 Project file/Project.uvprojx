# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: INIT.s Delay100.s Startup.s mainn.s cursor.s ship_load.s draw_border.s clear_SRAM.s clear_cursor.s cursor2.s timer.s SysTick_Handler.s numbers.s My_GPIOPortF_Handler.s put_battle.s put_civil.s clear_screen.s clear_SRAM_mine.s mine_load.s
